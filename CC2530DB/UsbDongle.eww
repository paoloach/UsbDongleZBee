<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\UsbDongle.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>UsbDongle</project>
        <configuration>CoordinatorEB</configuration>
      </member>
     </batchDefinition>
  </batchBuild>
</workspace>


